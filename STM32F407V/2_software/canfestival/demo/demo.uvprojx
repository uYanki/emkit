# Keil uVision project demo.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=25000000
  c include: ..\..\fwlib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\fwlib\Libraries\CMSIS\Include;..\..\board;.\Core\inc;..\..\3rdparty\canfestival\include;.\Core\src\CanFestival;.\Core\inc\canopen;.\Core\inc\canopen\dictionary
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./Core/src/: startup_stm32f40_41xxx.s
  group cmsis
    ./Core/src/: system_stm32f4xx.c
  group user
    ./Core/inc/: board_conf.h
    ../../board/: pinmap.h
    ./Core/src/: main.c stm32f4xx_it.c
  group bsp
    ../../board/bsp/: key.c led.c uart.c can.c
  group system
    ../../board/system/: autoinit.c buildtime.c sleep.c swrst.c
  group fwlib
    ../../fwlib/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group 3rdparty/canfestival
    ../../3rdparty/canfestival/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c symbols.c sync.c timer.c
  group 3rdparty/canfestival/port
    ./Core/inc/canopen/: config.h applicfg.h canfestival.h timerscfg.h
    ./Core/inc/canopen/dictionary/: master.c slave.c
