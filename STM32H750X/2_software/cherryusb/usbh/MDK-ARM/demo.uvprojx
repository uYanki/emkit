# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.8.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;C:/emkit/libc/stmicro/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc;C:/emkit/libc/stmicro/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;C:/emkit/libc/stmicro/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Device/ST/STM32H7xx/Include;C:/emkit/libc/stmicro/STM32Cube_FW_H7_V1.11.0/Drivers/CMSIS/Include;../../common/cherryusb/core;../../common/cherryusb/common;../../common/CherryUSB/osal;../../common/CherryUSB/third_party/FreeRTOS-10.4/include;../../common/CherryUSB/third_party/FreeRTOS-10.4/portable/GCC/ARM_CM7/r0p1;../../common/CherryUSB/class/hid;../../common/CherryUSB/class/video;../../common/CherryUSB/class/msc;../../common/CherryUSB/class/cdc;../../common/CherryUSB/class/audio;../../common/CherryUSB/class/hub;..\..\common\CherryUSB\class\vendor\serial
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../../common/CherryUSB/demo/: usb_host.c
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    C:/emkit/libc/stmicro/STM32Cube_FW_H7_V1.11.0/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middleware/CherryUSB
    ../../common/CherryUSB/port/dwc2/: usb_hc_dwc2.c
    ../../common/cherryusb/port/dwc2/: usb_glue_st.c
    ../../common/CherryUSB/osal/: usb_osal_freertos.c
    ../../common/CherryUSB/core/: usbh_core.c
    ../../common/CherryUSB/class/video/: usbh_video.c
    ../../common/CherryUSB/class/msc/: usbh_msc.c
    ../../common/CherryUSB/class/hid/: usbh_hid.c
    ../../common/CherryUSB/class/hub/: usbh_hub.c
    ../../common/CherryUSB/class/cdc/: usbh_cdc_acm.c
    ../../common/CherryUSB/class/audio/: usbh_audio.c
    ../../common/CherryUSB/class/vendor/serial/: usbh_ch34x.c usbh_cp210x.c usbh_ftdi.c usbh_pl2303.c
  group Middleware/FreeRTOS
    ../../common/CherryUSB/third_party/FreeRTOS-10.4/portable/MemMang/: heap_4.c
    ../../common/CherryUSB/third_party/FreeRTOS-10.4/portable/GCC/ARM_CM7/r0p1/: port.c
    ../../common/CherryUSB/third_party/FreeRTOS-10.4/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
software components: CMSIS:CORE 5.5.0
