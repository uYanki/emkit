# Keil uVision project demo.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=25000000
  c include: ..\..\fwlib\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\fwlib\Libraries\CMSIS\Include;..\..\board;.\Core\inc;..\..\3rdparty\freemodbus\modbus\include;.\Core\src\mbslave;..\..\3rdparty\freemodbus\modbus\rtu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./Core/src/: startup_stm32f40_41xxx.s
  group cmsis
    ./Core/src/: system_stm32f4xx.c
  group user
    ./Core/inc/: board_conf.h
    ./Core/src/: main.c stm32f4xx_it.c
  group system
    ../../board/system/: sleep.c autoinit.c
  group paratbl
    ./Core/inc/paratbl/: attr.h tbl.h
    ./Core/src/: paratbl.c
  group pulse
    ../../board/pulse/: wave.c calc.c
  group 3rdparty/modbus/core
    ../../3rdparty/freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../3rdparty/freemodbus/modbus/: mb.c
  group 3rdparty/modbus/rtu
    ../../3rdparty/freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
  group 3rdparty/modbus/port
    ./Core/src/mbslave/: mbslave.c portevent.c portserial.c porttimer.c
  group encoder
    ../../board/enc/: absEnc.c incEnc.c pulse.c hallEnc.c rotEnc.c
