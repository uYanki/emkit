# Keil uVision project Project.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: AIR001Dev Generic
  pack: Keil.AIR001_DFP.1.1.2
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,AIR001_DEV,CORE_DEBUG=0
  c include: ..\Inc;..\Bsp;C:\emkit\libc\openluat\AIR001\AIR001xx_HAL_Driver\Inc;C:\emkit\libc\openluat\AIR001\CMSIS\Include;C:\emkit\libc\openluat\AIR001\CMSIS\Include;C:\emkit\libc\openluat\AIR001\CMSIS\Device\AIR001xx\Include;..\..\common\CoreMark;..\..\common\CoreMark\simple
  asm define: USE_HAL_DRIVER,AIR001_DEV
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Drivers/AIR001xx_HAL_Driver
    C:/emkit/libc/openluat/AIR001/AIR001xx_HAL_Driver/Src/: air001xx_hal.c air001xx_hal_adc.c air001xx_hal_adc_ex.c air001xx_hal_can.c air001xx_hal_cec.c air001xx_hal_comp.c air001xx_hal_cortex.c air001xx_hal_crc.c air001xx_hal_crc_ex.c air001xx_hal_dac.c air001xx_hal_dac_ex.c air001xx_hal_dma.c air001xx_hal_exti.c air001xx_hal_flash.c air001xx_hal_gpio.c air001xx_hal_i2c.c air001xx_hal_i2c_ex.c air001xx_hal_i2s.c air001xx_hal_irda.c air001xx_hal_iwdg.c air001xx_hal_led.c air001xx_hal_lptim.c air001xx_hal_pcd.c air001xx_hal_pcd_ex.c air001xx_hal_pwr.c air001xx_hal_pwr_ex.c air001xx_hal_rcc.c air001xx_hal_rcc_ex.c air001xx_hal_rtc.c air001xx_hal_rtc_ex.c air001xx_hal_smartcard.c air001xx_hal_smartcard_ex.c air001xx_hal_smbus.c air001xx_hal_spi.c air001xx_hal_spi_ex.c air001xx_hal_tim.c air001xx_hal_tim_ex.c air001xx_hal_tsc.c air001xx_hal_uart.c air001xx_hal_usart.c air001xx_hal_wwdg.c air001xx_ll_adc.c air001xx_ll_comp.c air001xx_ll_crc.c air001xx_ll_crs.c air001xx_ll_dac.c air001xx_ll_dma.c air001xx_ll_exti.c air001xx_ll_gpio.c air001xx_ll_i2c.c air001xx_ll_led.c air001xx_ll_lptim.c air001xx_ll_pwr.c air001xx_ll_rcc.c air001xx_ll_rtc.c air001xx_ll_spi.c air001xx_ll_tim.c air001xx_ll_usart.c air001xx_ll_usb.c air001xx_ll_utils.c
  group Common
    ../Src/: system_air001xx.c
    ./: startup_air001_dev.s
  group Application/User
    ../Src/: air001xx_hal_msp.c air001xx_it.c main.c
    ../Bsp/: air001_Core_Board.c
  group CoreMark
    ../../common/CoreMark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
    ../../common/CoreMark/simple/: core_portme.c ee_printf.c
software components: CMSIS:CORE 5.5.0
